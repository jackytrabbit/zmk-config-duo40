## config/boards/arm/duo40/Kconfig.board
```kconfig
# Copyright (c) 2022 LAZYDESIGNERS
# SPDX-License-Identifier: MIT

config BOARD_DUO40
	bool "duo40"
	depends on SOC_NRF52840_QIAA
```
